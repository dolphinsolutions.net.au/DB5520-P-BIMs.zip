Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-03-20T08:25:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 20 08:25:09 2024 * Host: Yogoon * Database: C:\Users\gokul\AppData\Local\Temp\2e13ad9b-9c38-4c71-93a6-3bb9e012d381\27755046-ddd5-4c68-b494-93d636e14ed5\ifc * Database version: 5507 * Database creation date: Wed Mar 20 08:25:09 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 20 08:25:09 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 20 08:25:09 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: DB5520.P:DB5520.P, DB5520.P:DB5520.P:348505
In: Level 1
Pset_DistributionFlowElementCommon - Reference: DB5520.P:DB5520.P; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_DolphinBlueLowHeightFramelessCisternPneumatic; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: DolphinBlueLowHeightFramelessCisternPneumatic_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.526834 m2; Volume: 0.0253345 m3; Wall Thickness: 90 mm
Identity Data - Mark: 1
Other - Category: Plumbing Fixtures; Family: DB5520.P: DB5520.P; Family and Type: DB5520.P: DB5520.P; Type: DB5520.P: DB5520.P; Type Id: DB5520.P: DB5520.P
Phasing - Phase Created: New Construction
Constraints(Type) - Default Elevation: 0 mm
Dimensions(Type) - Depth: 150 mm; Height: 725 mm; Width: 440 mm
Identity Data(Type) - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_93_89 WC cisterns; CAWS: "N13/10 WC pans and flushing arrangements; CodePerformance: n/a; Constituents: n/a; Description: Dolphin Blue Low Height Frameless Cistern Pneumatic; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Form: In-Wall; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: www.dolphinsolutions.co.uk; ModelNumber: DB5520.P; ModelReference: DolphinSolutionsLimited_DolphinBlueLowHeightFramelessCisternPneumatic; Name: DolphinBlueLowHeightFramelessCisternPneumatic_DolphinSolutionsLimited; NBSDescription: WC cisterns; NBSTypeID: n/a; NominalDepth: 150; NominalHeight: 405; NominalLength: 440; ObjectClassification: 23.45.05.21.14.14; OmniClass Number: 23.45.05.21.11; OmniClass Title: Water Closets; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 405 x 440 x 150 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB5520.P; Uniclass2015Code: Pr_40_20_93_89; Uniclass2015Title: WC cisterns; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Other(Type) - Category: Plumbing Fixtures; Family Name: DB5520.P
